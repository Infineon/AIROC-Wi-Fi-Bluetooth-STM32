<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ble_wifi_onboarding.ewp</path>
  </project>
  <batchBuild />
</workspace>
