<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\wifi_mfg_tester_threadx.ewp</path>
  </project>
  <batchBuild />
</workspace>
