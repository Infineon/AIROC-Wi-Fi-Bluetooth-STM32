# IAR project wifi_scan.ewp, settings and files
configuration wifi_scan_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M4 ST STM32H747XI_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H747xx
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../Drivers/BSP/STM32H747I-DISCO; ../Common/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\CM4\Core\Inc
  OBJCOPY.OOCOutputFile: wifi_scan_CM4.hex
  ILINK.IlinkOutputFile: wifi_scan_CM4.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration wifi_scan_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../Common/Inc; ../Drivers/BSP/STM32H747I-DISCO; ../Drivers/BSP/Components/Common; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mw-core/lwip-whd-port/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mw-core/lwip-whd-port/arch/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mw-core/lwip-whd-port/arch; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mw-core/lwip-whd-port; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/COMPONENT_FREERTOS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43012; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/bus_protocols; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/nvram/TARGET_CY8CKIT_062S2_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/nvram/TARGET_CY8CKIT_062S2_43012
  AARM.AUserIncludes: ..\CM7\Core\Inc
  OBJCOPY.OOCOutputFile: wifi_scan_CM7.hex
  ILINK.IlinkOutputFile: wifi_scan_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: freertos.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c wifi_task.c
  group Drivers/BSP
    ../Drivers/BSP/STM32H747I-DISCO/: stm32h747i_discovery.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c
  group Middlewares/Connectivity/Documentation
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/: version.txt
  group Middlewares/Connectivity/Wireless/Platform/abstraction-rtos
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/: cy_worker_thread.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/: cy_worker_thread.h cyabs_rtos.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/: cyabs_freertos_helpers.c cyabs_rtos_freertos.c
  group Middlewares/Connectivity/Wireless/Platform/device/CYW43012
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012/: 43012C0-mfgtest_bin.c 43012C0-mfgtest_clm_blob.c 43012C0_bin.c 43012C0_clm_blob.c resources.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43012/: cy_chip_constants.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/inc/: whd_resource_api.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/: wiced_resource.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/nvram/TARGET_CY8CKIT_062S2_43012/: wifi_nvram_image.h
  group Middlewares/Connectivity/Wireless/Platform/pal
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include/: cy_result.h cy_utils.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include/: cyhal.h cyhal_adc.h cyhal_clock.h cyhal_comp.h cyhal_crc.h cyhal_dac.h cyhal_dma.h cyhal_ezi2c.h cyhal_flash.h cyhal_general_types.h cyhal_gpio.h cyhal_hwmgr.h cyhal_i2c.h cyhal_i2s.h cyhal_interconnect.h cyhal_lptimer.h cyhal_opamp.h cyhal_pdmpcm.h cyhal_pwm.h cyhal_qspi.h cyhal_rtc.h cyhal_sdhc.h cyhal_sdio.h cyhal_spi.h cyhal_syspm.h cyhal_system.h cyhal_timer.h cyhal_trng.h cyhal_uart.h cyhal_usb_dev.h cyhal_wdt.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc/: cyhal_hw_types.h stm32_cyhal_common.h stm32_cyhal_gpio_ex.h stm32_cyhal_gpio_pin.h stm32_cyhal_lptimer_ex.h stm32_cyhal_sdio_ex.h stm32_cyhal_spi_ex.h stm32_cyhal_uart_ex.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Src/: cyhal_system.c wifi_bt_if.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Src/: stm32_cyhal_gpio.c stm32_cyhal_lptimer.c stm32_cyhal_sdio.c stm32_cyhal_spi.c stm32_cyhal_trng.c stm32_cyhal_uart.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc/: wifi_bt_if.h
  group Middlewares/Connectivity/Wireless/Wifi/connectivity-utilities
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/: cy_json_parser.c cy_json_parser.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/: cy_linked_list.c cy_linked_list.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/: cy_log.c cy_log.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/COMPONENT_LWIP/: cy_nw_helper.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/: cy_nw_helper.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/: cy_result_mw.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/: cy_string_utils.c cy_string_utils.h
  group Middlewares/Connectivity/Wireless/Wifi/LwIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/apps/: altcp_proxyconnect.h altcp_tls_mbedtls_opts.h fs.h http_client.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_opts.h mdns_priv.h mqtt.h mqtt_opts.h mqtt_priv.h netbiosns.h netbiosns_opts.h smtp.h smtp_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_snmpv2_framework.h snmp_snmpv2_usm.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_opts.h tftp_server.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/stdc/: errno.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/netif/: ethernet.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/net/: if.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/arpa/: inet.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/: netdb.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/sys/: socket.h
  group Middlewares/Connectivity/Wireless/Wifi/wcm/LWIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_LWIP/: cy_wcm.c
  group Middlewares/Connectivity/Wireless/Wifi/whd-bsp-integration
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/: cy_network_buffer.c cy_network_buffer.h cybsp_wifi.c cybsp_wifi.h
  group Middlewares/Connectivity/Wireless/Wifi/wifi-host-driver
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/: whd_ap.c whd_buffer_api.c whd_cdc_bdc.c whd_chip.c whd_chip_constants.c whd_clm.c whd_debug.c whd_events.c whd_logging.c whd_management.c whd_network_if.c whd_resource_if.c whd_sdpcm.c whd_thread.c whd_utils.c whd_wifi.c whd_wifi_api.c whd_wifi_p2p.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include/: whd_ap.h whd_buffer_api.h whd_cdc_bdc.h whd_chip.h whd_chip_constants.h whd_clm.h whd_debug.h whd_endian.h whd_events_int.h whd_int.h whd_network_if.h whd_poll.h whd_resource_if.h whd_sdpcm.h whd_thread.h whd_thread_internal.h whd_types_int.h whd_utils.h whd_wifi_p2p.h whd_wlioctl.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/bus_protocols/: whd_bus.c whd_bus.h whd_bus_common.c whd_bus_common.h whd_bus_protocol_interface.h whd_bus_sdio_protocol.c whd_bus_sdio_protocol.h whd_bus_spi_protocol.c whd_bus_spi_protocol.h whd_chip_reg.h whd_sdio.h whd_spi.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/: whd_resources.c
  group Middlewares/Connectivity/Wireless/Wifi/wifi-mw-core
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mw-core/lwip-whd-port/arch/: cc.h sys_arch.c sys_arch.h
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mw-core/lwip-whd-port/: cy_lwip.c cy_lwip.h cy_lwip_dhcp_server.c cy_lwip_dhcp_server.h cy_lwip_error.h cy_lwip_log.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
