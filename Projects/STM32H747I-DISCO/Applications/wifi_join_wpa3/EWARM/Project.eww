<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\wifi_join_wpa3.ewp</path>
  </project>
  <batchBuild />
</workspace>
