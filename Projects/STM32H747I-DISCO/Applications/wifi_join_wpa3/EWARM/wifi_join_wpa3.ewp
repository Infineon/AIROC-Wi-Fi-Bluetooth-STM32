# IAR project wifi_join_wpa3.ewp, settings and files
configuration wifi_join_wpa3_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM4 ST STM32H747XI_CM4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H747xx
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../CM4/Core/Inc
  OBJCOPY.OOCOutputFile: wifi_join_wpa3_CM4.hex
  ILINK.IlinkOutputFile: wifi_join_wpa3_CM4.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration wifi_join_wpa3_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; CYBSP_WIFI_CAPABLE; CY_USING_HAL; CY_STORAGE_WIFI_DATA=".whd_fw"; STM32_THREAD_SAFE_STRATEGY=5
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/ARM/mbedtls/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/ARM/mbedtls/include/mbedtls/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/ARM/mbedtls/library/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wpa3-external-supplicant/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/bus_protocols; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/ARM/mbedtls/library; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/COMPONENT_FREERTOS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  AARM.AUserIncludes: ../CM7/Core/Inc
  OBJCOPY.OOCOutputFile: wifi_join_wpa3_CM7.hex
  ILINK.IlinkOutputFile: wifi_join_wpa3_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s dlib_lock_glue.c
  group Application/User/Core
    ../CM7/Core/Src/: wifi_task.c
  group Application/User/MBEDTLS
    ../CM7/MBEDTLS/Target/: hardware_rng.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Connectivity/Wireless/Wifi/network-interface/LWIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/: cy_ethernetif.c cy_lwip_dhcp_server.c cy_network_mw_core.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/arch/: sys_arch.c
  group Middlewares/Connectivity/Wireless/Wifi/wifi-host-driver
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/bus_protocols/: whd_bus.c whd_bus_common.c whd_bus_sdio_protocol.c whd_bus_spi_protocol.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/: whd_ap.c whd_buffer_api.c whd_cdc_bdc.c whd_chip.c whd_chip_constants.c whd_clm.c whd_debug.c whd_events.c whd_logging.c whd_management.c whd_network_if.c whd_resource_if.c whd_sdpcm.c whd_thread.c whd_utils.c whd_wifi.c whd_wifi_api.c whd_wifi_p2p.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/: whd_resources.c
  group Middlewares/Connectivity/Wireless/Wifi/wcm/WCM
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/: cy_wcm.c
  group Middlewares/Connectivity/Wireless/Wifi/connectivity-utilities
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/: cy_log.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/: cy_json_parser.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/: cy_linked_list.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/: cy_string_utils.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/: cy_nw_helper_common.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/COMPONENT_LWIP/: cy_nw_helper.c
  group Middlewares/Connectivity/Wireless/Wifi/mbedtls
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/ARM/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c pk_wrap.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_driver_wrappers.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509write_crt.c x509write_csr.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
  group Middlewares/Connectivity/Wireless/Wifi/whd-bsp-integration
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/: cybsp_wifi.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/COMPONENT_LWIP/: cy_network_buffer_lwip.c
  group Middlewares/Connectivity/Wireless/Wifi/LwIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/netif/: ethernet.c
  group Middlewares/Connectivity/Wireless/Wifi/wpa3-external-supplicant
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wpa3-external-supplicant/source/: wpa3_ext_supp.c wpa3_ext_crypto.c wpa3_ext_utils.c
  group Middlewares/Connectivity/Documentation
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/: generated_mac_address.txt
  group Middlewares/Connectivity/Wireless/Platform/pal
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Src/: cyhal_system.c wifi_bt_if.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Src/: stm32_cyhal_gpio.c stm32_cyhal_lptimer.c stm32_cyhal_sdio.c stm32_cyhal_spi.c stm32_cyhal_trng.c stm32_cyhal_uart.c
  group Middlewares/Connectivity/Wireless/Platform/abstraction-rtos/FreeRTOS
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/: cyabs_freertos_helpers.c cyabs_rtos_freertos.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/: cy_worker_thread.c
