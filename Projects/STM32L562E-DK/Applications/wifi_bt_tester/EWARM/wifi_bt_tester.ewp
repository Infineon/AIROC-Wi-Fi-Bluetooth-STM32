# IAR project wifi_bt_tester.ewp, settings and files
configuration wifi_bt_tester (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CYBSP_WIFI_CAPABLE; HAVE_SNPRINTF; CY_USING_HAL; DISABLE_COMMAND_CONSOLE_BT; CY_STORAGE_WIFI_DATA=".whd_fw"; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; USE_HAL_DRIVER; STM32L562xx; STM32_THREAD_SAFE_STRATEGY=5
  ICCARM.CCIncludePath2: ../Core/Inc; ../MBEDTLS/App; ../Drivers/STM32L5xx_HAL_Driver/Inc; ../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure; ../Middlewares/Third_Party/mbedTLS/include/mbedtls; ../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../Middlewares/Third_Party/mbedTLS/include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/secure-sockets/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/secure-sockets/source/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/bus_protocols; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/clm/COMPONENT_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/nvram/COMPONENT_43012/COMPONENT_MURATA-1LV/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/COMPONENT_FREERTOS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43012; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/clm/COMPONENT_43012; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/common/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/debug/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack/wiced_include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack/wiced_include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/bluetooth_utility/COMPONENT_WICED_BLE/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/command_console/COMPONENT_PSOC6HAL/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/include/COMPONENT_SECURE_SOCKETS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/rtos/COMPONENT_SECURE_SOCKETS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/bluetooth_utility/COMPONENT_WICED_BLE; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/command_console/COMPONENT_PSOC6HAL; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/rtos/COMPONENT_SECURE_SOCKETS; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf_utility; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/wifi_utility; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/include/COMPONENT_SECURE_SOCKETS; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/include; ../Drivers/BSP/Components/mx25lm51245g; ../Drivers/BSP/STM32L562E-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: wifi_bt_tester.hex
  ILINK.IlinkOutputFile: wifi_bt_tester.out
  ILINK.IlinkIcfFile: stm32l562xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: dlib_lock_glue.c startup_stm32l562xx.s
  group Application/User/Core
    ../Core/Src/: app_freertos.c console_task.c main.c stm32l5xx_hal_msp.c stm32l5xx_hal_timebase_tim.c stm32l5xx_it.c
  group Application/User/MBEDTLS/App
    ../MBEDTLS/App/: mbedtls.c
  group Application/User/MBEDTLS/Target
    ../MBEDTLS/Target/: hardware_rng.c
  group Drivers/BSP/STM32L552E-EV
    ../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery_ospi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_lptim.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rng_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_ll_sdmmc.c
  group Middlewares/Connectivity/Documentation
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/: generated_mac_address.txt
  group Middlewares/Connectivity/Wireless/Bluetooth/btstack-integration
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/debug/: cybt_debug_uart.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/common/: cybt_hci_rx_task.c cybt_hci_tx_task.c cybt_host_stack_platform_interface.c cybt_patchram_download.c cybt_platform_main.c cybt_platform_task.c cybt_platform_trace.c cybt_prm.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/freertos/: cybt_platform_freertos.c
  group Middlewares/Connectivity/Wireless/Bluetooth/btstack/BLE_HARDFP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack/stack/COMPONENT_WICED_BLE/COMPONENT_CM33/COMPONENT_HARDFP/TOOLCHAIN_IAR/: libbtstack.a
  group Middlewares/Connectivity/Wireless/MfgTools/command-console
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/bluetooth_utility/COMPONENT_WICED_BLE/: bt_cfg.c bt_utility.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/src/: checkdelay.c checkisoch.cpp checkpdfs.c checksums.c Client.cpp Extractor.c gnu_getopt.c gnu_getopt_long.c histogram.c igmp_querier.c iperf_main.cpp IperfList.cpp isochronous.cpp Launch.cpp Listener.cpp Locale.c pdfs.c PerfSocket.cpp ReportCSV.c ReportDefault.c Reporter.c Server.cpp service.c Settings.cpp SocketAddr.c sockets_iperf.c stdio.c tcp_window_size.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/include/: Client.hpp isochronous.hpp Listener.hpp PerfSocket.hpp Server.hpp Settings.hpp Timestamp.hpp
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/command_console/: command_console.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/command_console/COMPONENT_PSOC6HAL/: command_utility.cpp
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/rtos/COMPONENT_SECURE_SOCKETS/: condition.c iperf_debug.c iperf_getopt_long.c iperf_sockets.c rtos_gettimeofday.c thread.c usleep.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf/compat/: delay.c gettimeofday.c inet_ntop.c inet_pton.c iperf_error.c signal.c snprintf.c string.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/iperf_utility/: iperf_utility.cpp
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/command-console/source/wifi_utility/COMPONENT_WCM/: wifi_utility.c
  group Middlewares/Connectivity/Wireless/Platform/abstraction-rtos/FreeRTOS
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/: cy_worker_thread.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/: cyabs_freertos_helpers.c cyabs_rtos_freertos.c
  group Middlewares/Connectivity/Wireless/Platform/module/MURATA-1LV
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012/: 43012C0-mfgtest_bin.c 43012C0_bin.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/clm/COMPONENT_43012/COMPONENT_MURATA-1LV/: 43012C0-mfgtest_clm_blob.c 43012C0_clm_blob.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/firmware/COMPONENT_43012/COMPONENT_MURATA-1LV/: w_bt_firmware_controller.c
  group Middlewares/Connectivity/Wireless/Platform/pal
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Src/: cyhal_system.c wifi_bt_if.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Src/: stm32_cyhal_gpio.c stm32_cyhal_lptimer.c stm32_cyhal_sdio.c stm32_cyhal_spi.c stm32_cyhal_trng.c stm32_cyhal_uart.c
  group Middlewares/Connectivity/Wireless/Wifi/connectivity-utilities
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/: cy_json_parser.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/: cy_linked_list.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/: cy_log.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/COMPONENT_LWIP/: cy_nw_helper.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/: cy_nw_helper_common.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/: cy_string_utils.c
  group Middlewares/Connectivity/Wireless/Wifi/LwIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/netif/: ethernet.c
  group Middlewares/Connectivity/Wireless/Wifi/network-interface/LWIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/: cy_ethernetif.c cy_lwip_dhcp_server.c cy_network_mw_core.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/arch/: sys_arch.c
  group Middlewares/Connectivity/Wireless/Wifi/secure-sockets
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/secure-sockets/source/: cy_pkcs_psa_logging.c cy_tls_weak.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/secure-sockets/source/COMPONENT_LWIP/: cy_secure_sockets.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/secure-sockets/source/COMPONENT_MBEDTLS/: cy_tls.c iot_crypto.c
  group Middlewares/Connectivity/Wireless/Wifi/wcm/WCM
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/: cy_wcm.c
  group Middlewares/Connectivity/Wireless/Wifi/whd-bsp-integration
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/COMPONENT_LWIP/: cy_network_buffer_lwip.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/: cybsp_wifi.c
  group Middlewares/Connectivity/Wireless/Wifi/wifi-host-driver
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/: whd_ap.c whd_buffer_api.c whd_cdc_bdc.c whd_chip.c whd_chip_constants.c whd_clm.c whd_debug.c whd_events.c whd_logging.c whd_management.c whd_network_if.c whd_resource_if.c whd_sdpcm.c whd_thread.c whd_utils.c whd_wifi.c whd_wifi_api.c whd_wifi_p2p.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/bus_protocols/: whd_bus.c whd_bus_common.c whd_bus_sdio_protocol.c whd_bus_spi_protocol.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/: whd_resources.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c camellia.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c ctr_drbg.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c md.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c platform_util.c poly1305.c rsa_internal.c sha256.c sha512.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c version_features.c x509.c x509_crt.c
    ../Middlewares/Third_Party/mbedTLS/include/: CMakeLists.txt
