<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\bt_mfg_tester.ewp</path>
  </project>
  <batchBuild />
</workspace>
