# IAR project wifi_mfg_tester.ewp, settings and files
configuration wifi_mfg_tester (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575AI ST STM32U575AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: WLAN_MFG_FIRMWARE; CYBSP_WIFI_CAPABLE; USE_HAL_DRIVER; STM32U575xx; STM32_THREAD_SAFE_STRATEGY=2; CY_USING_HAL
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/bus_protocols; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/COMPONENT_FREERTOS/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/inc; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include; ../Middlewares/Third_Party/Infineon_RTOS_Middleware/FreeRTOS/Source/CMSIS_RTOS_V2/; ../Middlewares/Third_Party/Infineon_RTOS_Middleware/FreeRTOS/Source/include/; ../Middlewares/Third_Party/Infineon_RTOS_Middleware/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../Middlewares/Third_Party/Infineon_RTOS_Middleware/FreeRTOS/Source/include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mfg-test/include/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mfg-test/source; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mfg-test/include; ../Drivers/CMSIS/RTOS2/Include; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/clm/COMPONENT_43012/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/nvram/COMPONENT_43012/COMPONENT_MURATA-1LV/; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43012; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012; ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/clm/COMPONENT_43012
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: wifi_mfg_tester.hex
  ILINK.IlinkOutputFile: wifi_mfg_tester.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: dlib_lock_glue.c startup_stm32u575xx.s dlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: mfg_test_client_task.c main.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_sdmmc.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/Connectivity/Wireless/Wifi/network-interface/LWIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/: cy_ethernetif.c cy_lwip_dhcp_server.c cy_network_mw_core.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/arch/: sys_arch.c
  group Middlewares/Connectivity/Wireless/Wifi/wifi-host-driver
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/bus_protocols/: whd_bus.c whd_bus_common.c whd_bus_sdio_protocol.c whd_bus_spi_protocol.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/src/: whd_ap.c whd_buffer_api.c whd_cdc_bdc.c whd_chip.c whd_chip_constants.c whd_clm.c whd_debug.c whd_events.c whd_logging.c whd_management.c whd_network_if.c whd_resource_if.c whd_sdpcm.c whd_thread.c whd_utils.c whd_wifi.c whd_wifi_api.c whd_wifi_p2p.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/resource_imp/: whd_resources.c
  group Middlewares/Connectivity/Wireless/Wifi/wcm/WCM
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/: cy_wcm.c
  group Middlewares/Connectivity/Wireless/Wifi/connectivity-utilities
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/: cy_log.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/: cy_json_parser.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/: cy_linked_list.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/: cy_string_utils.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/: cy_nw_helper_common.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/COMPONENT_LWIP/: cy_nw_helper.c
  group Middlewares/Connectivity/Wireless/Wifi/whd-bsp-integration
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/: cybsp_wifi.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/COMPONENT_LWIP/: cy_network_buffer_lwip.c
  group Middlewares/Connectivity/Wireless/Wifi/LwIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/netif/: ethernet.c
  group Middlewares/Connectivity/Documentation
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/: generated_mac_address.txt
  group Middlewares/Connectivity/Wireless/Platform/module/MURATA-1LV
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/firmware/COMPONENT_43012/: 43012C0_bin.c 43012C0-mfgtest_bin.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/resources/clm/COMPONENT_43012/COMPONENT_MURATA-1LV/: 43012C0-mfgtest_clm_blob.c 43012C0_clm_blob.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/firmware/COMPONENT_43012/COMPONENT_MURATA-1LV/: w_bt_firmware_controller.c
  group Middlewares/Connectivity/Wireless/Platform/pal
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Src/: cyhal_system.c wifi_bt_if.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Src/: stm32_cyhal_gpio.c stm32_cyhal_lptimer.c stm32_cyhal_sdio.c stm32_cyhal_spi.c stm32_cyhal_trng.c stm32_cyhal_uart.c
  group Middlewares/Connectivity/Wireless/Platform/abstraction-rtos/FreeRTOS
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/: cyabs_freertos_helpers.c cyabs_rtos_freertos.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/: cy_worker_thread.c
  group Middlewares/Connectivity/Wireless/MfgTools/wifi-mfg-test
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mfg-test/source/: mfg_test_common.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-mfg-test/target/COMPONENT_WCM/: mfg_test_comp_ioctl.c
  group Middlewares/Middleware/RTOS/FreeRTOS/heap/Heap_4
    ../Middlewares/Third_Party/Infineon_RTOS_Middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/Middleware/RTOS/FreeRTOS/core
    ../Middlewares/Third_Party/Infineon_RTOS_Middleware/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/Infineon_RTOS_Middleware/FreeRTOS/Source/: list.c queue.c tasks.c croutine.c event_groups.c stream_buffer.c timers.c
    ../Middlewares/Third_Party/Infineon_RTOS_Middleware/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
