# IAR project ble_wifi_onboarding.ewp, settings and files
configuration ble_wifi_onboarding (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575AI ST STM32U575AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CYBSP_WIFI_CAPABLE; CY_USING_HAL; USE_HAL_DRIVER; STM32U575xx; STM32_THREAD_SAFE_STRATEGY=5
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include; ../Core/configs; ../Drivers/CMSIS/RTOS2/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: ble_wifi_onboarding.hex
  ILINK.IlinkOutputFile: ble_wifi_onboarding.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s dlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: app.c app_utils.c wifi_task.c main.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
    ../Core/configs/: app_platform_cfg.c cycfg_bt_settings.c cycfg_gap.c cycfg_gatt_db.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_lptim.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
